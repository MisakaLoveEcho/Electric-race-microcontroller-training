# Keil uVision project G474VET6Test.uvprojx, settings and files
target G474VET6Test (6220000::V6.22::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G474VET6Test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../LCD;../BSP;../ARM_DSP/Include;../ARM_DSP/PrivateInclude
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_rcc.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../BSP/: myuart.c myuart.h key.c key.h fft.c fft.h filter.c filter.h
  group DSP
    ../ARM_DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../ARM_DSP/Source/BayesFunctions/: BayesFunctions.c
    ../ARM_DSP/Source/CommonTables/: CommonTables.c
    ../ARM_DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../ARM_DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../ARM_DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../ARM_DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../ARM_DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../ARM_DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../ARM_DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../ARM_DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../ARM_DSP/Source/SupportFunctions/: SupportFunctions.c
    ../ARM_DSP/Source/SVMFunctions/: SVMFunctions.c
    ../ARM_DSP/Source/TransformFunctions/: TransformFunctions.c
    ../ARM_DSP/Source/WindowFunctions/: WindowFunctions.c
software components: CMSIS:CORE 6.1.0
